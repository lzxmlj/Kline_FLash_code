# Keil uVision project Nucleo411.uvproj, settings and files
target Nucleo411 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: Nucleo411 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\CMSIS;..\STM_Lib\inc;..\USER;..\FATFS;..\BoardHardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ../StartUp/: startup_stm32f411xe.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group STM_Lib
    ../STM_Lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group USER
    ../USER/: main.c stm32f4xx_it.c usart.c delay.c
  group BoardHardware
    ../BoardHardware/: SPI1.c
  group FATFS
    ../FATFS/: diskio.c ff.c MMC_SD.c
