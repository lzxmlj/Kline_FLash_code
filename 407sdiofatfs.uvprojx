# Keil uVision project 407sdiofatfs.uvprojx, settings and files
target 407 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 407sdiofatfs +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\STM_Lib\inc;.\USER;.\CMSIS;.\BoardHardware;.\FATFS\src;.\FATFS\exfuns;.\MALLOC
  asm misc: --cpreproc
  asm include: .\STM_Lib\inc;.\USER;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\407sdiofatfs.sct
  group BoardHardware
    ./BoardHardware/: SPI1.c SPI1.h w25qxx.c w25qxx.h sram.c
  group CMSIS
    ./CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h sys.c sys.h
  group FATFS
    ./FATFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./FATFS/exfuns/: exfuns.c exfuns.h fattester.c fattester.h
    ./FATFS/src/option/: unicode.c
  group StartUp
    ./StartUp/: startup_stm32f407xx.s
  group STM_Lib
    ./STM_Lib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_crc.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_hash.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_qspi.h stm32f4xx_rng.h stm32f4xx_sai.h stm32f4xx_spdifrx.h
    ./STM_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_spdifrx.c
  group USER
    ./USER/: BitBand.h delay.c delay.h main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h can.c sdio_sdcard.c sdio_sdcard.h usart.c
  group MALLOC
    ./MALLOC/: malloc.c malloc.h
